# Keil uVision project DHT11_ToOneNetByMqtt.uvprojx, settings and files
target 工程 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 工程文件 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\HARDWARE\inc;..\CORE;..\STLIB\inc;..\HMAC\inc;..\SYS;..\MYLIB\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/scr/: stm32f10x_it.c delay.c usart1.c usart2.c timer2.c timer3.c timer4.c
  group CORE
    ../CORE/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group STLIB
    ../STLIB/src/: misc.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_i2c.c
  group SYS
    ../SYS/: sys.c
  group MYLIB
    ../MYLIB/src/: adc.c beep.c control.c led.c light.c MQ_7.c mqtt.c myiic.c SHT30.c wifi.c dht11.c onenet.c gps_config.c nema_decode_test.c
  group nmea
    ../nmea/: context.c generate.c generator.c gmath.c info.c parse.c parser.c sentence.c time.c tok.c
